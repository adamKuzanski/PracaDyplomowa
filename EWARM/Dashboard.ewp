# IAR project Dashboard.ewp, settings and files
configuration STM32F746G-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_BPP=24
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ../TouchGFX/target; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/gui/include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ..\Drivers\BSP\STM32746G-Discovery; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STM32F746G-DISCO.hex
  ILINK.IlinkOutputFile: STM32F746G-DISCO.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.cpp stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c main.cpp freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp HW_Init.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7Instrumentation.cpp STM32F7TouchController.cpp BoardConfiguration.cpp GPIO.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7TouchController.cpp STM32F7Instrumentation.cpp HW_Init.cpp
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_digifit_20_4bpp_0.cpp Font_ntailu_20_4bpp_0.cpp Font_twenty_seven_regular_13_4bpp_0.cpp Font_twenty_seven_regular_20_4bpp_0.cpp Font_twenty_seven_regular_35_4bpp_0.cpp Font_twenty_seven_regular_91_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_digifit_20_4bpp.cpp Kerning_ntailu_20_4bpp.cpp Kerning_twenty_seven_regular_13_4bpp.cpp Kerning_twenty_seven_regular_20_4bpp.cpp Kerning_twenty_seven_regular_35_4bpp.cpp Kerning_twenty_seven_regular_91_4bpp.cpp Kerning_verdana_20_4bpp.cpp Table_digifit_20_4bpp.cpp Table_ntailu_20_4bpp.cpp Table_twenty_seven_regular_13_4bpp.cpp Table_twenty_seven_regular_20_4bpp.cpp Table_twenty_seven_regular_35_4bpp.cpp Table_twenty_seven_regular_91_4bpp.cpp Table_verdana_20_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/dashboard_screen
    ../TouchGFX/generated/gui_generated/src/dashboard_screen/: DashboardViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/intro_screen
    ../TouchGFX/generated/gui_generated/src/intro_screen/: IntroViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/secretmode_screen
    ../TouchGFX/generated/gui_generated/src/secretmode_screen/: SecretModeViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: bg_large_circle_custom.cpp bg_large_circle_test.cpp BitmapDatabase.cpp cruiseControl.cpp ecoMode.cpp handBrake.cpp leftIndicator.cpp logo_Lodz_Solar_Team.cpp longLights.cpp lowBeamLights.cpp lowEnergy.cpp neutralGear.cpp parkLights.cpp powerMode.cpp reverseGear.cpp rightIndicator.cpp YellowWarning.cpp
  group Application/User/TouchGFX/generated/images/__designer
    ../TouchGFX/generated/images/src/__designer/: Dark_ProgressIndicators_bg_large_circle_indicator_bg_line_full.cpp Dark_ProgressIndicators_bg_medium_progress_indicator_bg_square_90_degrees.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/dashboard_screen
    ../TouchGFX/gui/src/dashboard_screen/: DashboardPresenter.cpp DashboardView.cpp
  group Application/User/TouchGFX/gui/intro_screen
    ../TouchGFX/gui/src/intro_screen/: IntroPresenter.cpp IntroView.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/secretmode_screen
    ../TouchGFX/gui/src/secretmode_screen/: SecretModePresenter.cpp SecretModeView.cpp
  group Drivers/BSP
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_qspi.c stm32746g_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s port.c portasm.s
  group Middlewares/TouchGFX
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp OSWrappers.cpp
    ../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core_release.a touchgfx_core_release.a
